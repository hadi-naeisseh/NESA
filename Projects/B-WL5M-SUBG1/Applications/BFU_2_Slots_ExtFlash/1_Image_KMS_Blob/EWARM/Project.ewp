# IAR project Project.ewp, settings and files
configuration B-WL5M-SUBG1_1_Image_KMS_Blob (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL5MOC_M4 ST STM32WL5MOC_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; STM32WL5Mxx
  ICCARM.CCIncludePath2: ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/B-WL5M-SUBG; ..\..\..\..\..\..\Middlewares\ST\STM32_Key_Management_Services\Core; ..\..\1_Image_SECoreBin\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\..\KMS_Blob.bin
  postbuild: cmd /C "cmd /C postbuild.bat "$PROJ_DIR$" "KMS_Blob" 1 "
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32wl5mxx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: kms_blob_example_keys.c
