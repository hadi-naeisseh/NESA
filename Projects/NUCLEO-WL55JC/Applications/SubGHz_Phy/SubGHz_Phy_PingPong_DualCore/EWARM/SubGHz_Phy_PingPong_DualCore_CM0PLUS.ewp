# IAR project SubGHz_Phy_PingPong_DualCore_CM0PLUS.ewp, settings and files
configuration SubGHz_Phy_PingPong_DualCore_CM0PLUS (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL55JC_M0+ ST STM32WL55JC_M0+
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CORE_CM0PLUS; USE_HAL_DRIVER; STM32WL55xx
  ICCARM.CCIncludePath2: ../CM0PLUS/Core/Inc; ../CM0PLUS/SubGHz_Phy/App; ../CM0PLUS/SubGHz_Phy/Target; ../CM0PLUS/MbMux; ../Common/Board; ../Common/System; ../Common/MbMux; ../../../../../../Drivers/BSP/STM32WLxx_Nucleo; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy; ../../../../../../Utilities/misc; ../../../../../../Utilities/sequencer; ../../../../../../Utilities/timer; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include; ../../../../../../Middlewares/Third_Party/SubGHz_Phy; ../../../../../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver; ../../../../../../Drivers/CMSIS/Include; C:/Users/Hadi/STM32Cube/Repository/STM32Cube_FW_WL_V1.4.0/Utilities/trace/adv_trace; C:/Users/Hadi/STM32Cube/Repository/STM32Cube_FW_WL_V1.4.0/Drivers/STM32WLxx_HAL_Driver/Inc; C:/Users/Hadi/STM32Cube/Repository/STM32Cube_FW_WL_V1.4.0/Drivers/STM32WLxx_HAL_Driver/Inc/Legacy; C:/Users/Hadi/STM32Cube/Repository/STM32Cube_FW_WL_V1.4.0/Utilities/misc; C:/Users/Hadi/STM32Cube/Repository/STM32Cube_FW_WL_V1.4.0/Utilities/sequencer; C:/Users/Hadi/STM32Cube/Repository/STM32Cube_FW_WL_V1.4.0/Utilities/timer; C:/Users/Hadi/STM32Cube/Repository/STM32Cube_FW_WL_V1.4.0/Utilities/lpm/tiny_lpm; C:/Users/Hadi/STM32Cube/Repository/STM32Cube_FW_WL_V1.4.0/Drivers/CMSIS/Device/ST/STM32WLxx/Include; C:/Users/Hadi/STM32Cube/Repository/STM32Cube_FW_WL_V1.4.0/Middlewares/Third_Party/SubGHz_Phy; C:/Users/Hadi/STM32Cube/Repository/STM32Cube_FW_WL_V1.4.0/Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver; C:/Users/Hadi/STM32Cube/Repository/STM32Cube_FW_WL_V1.4.0/Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SubGHz_Phy_PingPong_DualCore_CM0PLUS.hex
  ILINK.IlinkOutputFile: SubGHz_Phy_PingPong_DualCore_CM0PLUS.out
  ILINK.IlinkIcfFile: stm32wl55xx_flash_cm0plus.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wl55xx_cm0plus.s
  group Application/User/CM0PLUS/Core
    ../CM0PLUS/Core/Src/: main.c gpio.c ipcc.c rtc.c subghz.c ipcc_if.c stm32_lpm_if.c sys_app.c timer_if.c stm32wlxx_it.c stm32wlxx_hal_msp.c
  group Application/User/CM0PLUS/MbMux
    ../CM0PLUS/MbMux/: features_info.c mbmux.c mbmuxif_radio.c mbmuxif_sys.c mbmuxif_trace.c radio_mbwrapper.c
  group Application/User/CM0PLUS/SubGHz_Phy/App
    ../CM0PLUS/SubGHz_Phy/App/: app_subghz_phy.c
  group Application/User/CM0PLUS/SubGHz_Phy/Target
    ../CM0PLUS/SubGHz_Phy/Target/: radio_board_if.c
  group Application/User/Common/System
    ../Common/System/: sys_debug.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32WLxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WLxx_Nucleo/: stm32wlxx_nucleo.c stm32wlxx_nucleo_radio.c
  group Drivers/CMSIS
    ../Common/System/: system_stm32wlxx.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal.c stm32wlxx_hal_cortex.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_exti.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_ipcc.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_subghz.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c
    C:/Users/Hadi/STM32Cube/Repository/STM32Cube_FW_WL_V1.4.0/Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c stm32wlxx_hal_ipcc.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_subghz.c
  group Middlewares/SubGHz_Phy
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver/: lr_fhss_mac.c radio.c radio_driver.c radio_fw.c wl_lr_fhss.c
    C:/Users/Hadi/STM32Cube/Repository/STM32Cube_FW_WL_V1.4.0/Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver/: lr_fhss_mac.c radio.c radio_driver.c radio_fw.c wl_lr_fhss.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/timer/: stm32_timer.c
    C:/Users/Hadi/STM32Cube/Repository/STM32Cube_FW_WL_V1.4.0/Utilities/trace/adv_trace/: stm32_adv_trace.c
    C:/Users/Hadi/STM32Cube/Repository/STM32Cube_FW_WL_V1.4.0/Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    C:/Users/Hadi/STM32Cube/Repository/STM32Cube_FW_WL_V1.4.0/Utilities/sequencer/: stm32_seq.c
    C:/Users/Hadi/STM32Cube/Repository/STM32Cube_FW_WL_V1.4.0/Utilities/timer/: stm32_timer.c
    C:/Users/Hadi/STM32Cube/Repository/STM32Cube_FW_WL_V1.4.0/Utilities/lpm/tiny_lpm/: stm32_lpm.c
